options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fm_channelizer
    output_language: python
  states: {}

blocks:
- name: address
  id: variable
  parameters:
    value: '""'
  states: {}
- name: atten
  id: variable
  parameters:
    value: '80'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: 60e3
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 101.1e6+0e3
  states: {}
- name: ch_bw
  id: variable
  parameters:
    value: ch_rate/2
  states: {}
- name: ch_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: ch_tb
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: channel
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Output Channel
    start: '0'
    step: '1'
    stop: channels-1
    value: '0'
  states: {}
- name: channels
  id: variable
  parameters:
    value: '10'
  states: {}
- name: fm_audio_decim
  id: variable
  parameters:
    value: int(fm_quad_rate/audio_rate)*2
  states: {}
- name: fm_quad_rate
  id: variable
  parameters:
    value: ch_rate*synth_channels
  states: {}
- name: freq_corr
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Frequency Correction
    start: '-40e3'
    step: '100'
    stop: 40e3
    value: '0'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: pfb_synth_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(channels/2, synth_channels*ch_rate, ch_bw, ch_tb, atten, window.WIN_BLACKMAN_HARRIS)
  states: {}
- name: pfb_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, samp_rate, ch_bw, ch_tb, atten, window.WIN_BLACKMAN_HARRIS)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: ch_rate*channels
  states: {}
- name: synth_channels
  id: variable
  parameters:
    value: '6'
  states: {}
- name: tun_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Gain (dB)
    start: '0'
    step: '1'
    stop: '70'
    value: gain
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.1'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_wfm_rcv
  id: analog_wfm_rcv
  parameters:
    audio_decimation: fm_audio_decim
    quad_rate: fm_quad_rate
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: channels-synth_channels
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '2'
    taps: 'firdes.low_pass_2(1, ch_rate*synth_channels, 250e3, 300e3, 40, window.WIN_BLACKMAN_HARRIS) '
    type: ccc
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 44.1e3/(fm_quad_rate/fm_audio_decim)
    type: fff
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: atten
    ch_map: ''
    nchans: channels
    osr: '2.0'
    taps: pfb_taps
  states: {}
- name: pfb_channelizer_hier_ccf_0
  id: pfb_channelizer_hier_ccf
  parameters:
    atten: '100'
    bw: '1.0'
    n_filterbanks: '4'
    outchans: None
    ripple: '0.1'
    taps: None
    tb: '0.2'
  states: {}
- name: pfb_synthesizer_ccf_0
  id: pfb_synthesizer_ccf
  parameters:
    ch_map: '[10, 11, 0, 1, 2, 3]'
    connections: synth_channels
    numchans: synth_channels
    taps: pfb_synth_taps
    twox: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,2
    name: QT GUI Plot
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: ch_rate*2
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,1
    label2: ''
    label3: ''
    label4: ''
    label5: ''
    label6: ''
    name: QT GUI Plot
    nconnections: synth_channels
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: ch_rate*synth_channels
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,1,1
    name: QT GUI Plot
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq + freq_corr
    clock_rate: '0.0'
    dev_addr: address
    gain0: tun_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc2_xx_0, '0', pfb_channelizer_ccf_0, '0']
- [analog_agc2_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx, '0', audio_sink, '0']
- [fir_filter_xxx_0, '0', analog_wfm_rcv, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_multiply_const_vxx, '0']
- [pfb_channelizer_ccf_0, '0', pfb_synthesizer_ccf_0, '0']
- [pfb_channelizer_ccf_0, '0', qtgui_freq_sink_x_0_0, '0']
- [pfb_channelizer_ccf_0, '1', pfb_synthesizer_ccf_0, '1']
- [pfb_channelizer_ccf_0, '1', qtgui_freq_sink_x_0_0, '1']
- [pfb_channelizer_ccf_0, '2', pfb_synthesizer_ccf_0, '2']
- [pfb_channelizer_ccf_0, '2', qtgui_freq_sink_x_0_0, '2']
- [pfb_channelizer_ccf_0, '3', pfb_synthesizer_ccf_0, '3']
- [pfb_channelizer_ccf_0, '3', qtgui_freq_sink_x_0_0, '3']
- [pfb_channelizer_ccf_0, '4', pfb_synthesizer_ccf_0, '4']
- [pfb_channelizer_ccf_0, '4', qtgui_freq_sink_x_0_0, '4']
- [pfb_channelizer_ccf_0, '5', pfb_synthesizer_ccf_0, '5']
- [pfb_channelizer_ccf_0, '5', qtgui_freq_sink_x_0_0, '5']
- [pfb_channelizer_ccf_0, '6', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '7', blocks_null_sink_0, '1']
- [pfb_channelizer_ccf_0, '8', blocks_null_sink_0, '2']
- [pfb_channelizer_ccf_0, '9', blocks_null_sink_0, '3']
- [pfb_synthesizer_ccf_0, '0', fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_agc2_xx_0, '0']
- [uhd_usrp_source_0, '0', analog_agc2_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
