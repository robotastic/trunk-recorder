options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fm_channelize_and_view
    output_language: python
  states: {}

blocks:
- name: address
  id: variable
  parameters:
    value: '""'
  states: {}
- name: atten
  id: variable
  parameters:
    value: '60'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 97.9e6
  states: {}
- name: ch1
  id: variable
  parameters:
    value: '5'
  states: {}
- name: ch2
  id: variable
  parameters:
    value: '22'
  states: {}
- name: ch_bw
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: ch_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: ch_tb
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: channels
  id: variable
  parameters:
    value: '10'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '65'
  states: {}
- name: pfb_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, samp_rate, ch_bw, ch_tb, atten, window.WIN_HANN)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: ch_rate*channels
  states: {}
- name: tun_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Gain (dB)
    start: '0'
    step: '0.5'
    stop: '73'
    value: gain
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.1'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: channels
    type: complex
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: atten
    ch_map: '[]'
    nchans: channels
    osr: '1.0'
    taps: pfb_taps
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,2
    name: QT GUI Plot
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: ch_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,1
    name: QT GUI Plot
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: ch_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,1,1
    name: QT GUI Plot
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: address
    gain0: tun_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc2_xx_0, '0', pfb_channelizer_ccf_0, '0']
- [analog_agc2_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [pfb_channelizer_ccf_0, '0', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_null_sink_0, '1']
- [pfb_channelizer_ccf_0, '2', blocks_null_sink_0, '2']
- [pfb_channelizer_ccf_0, '3', blocks_null_sink_0, '3']
- [pfb_channelizer_ccf_0, '4', blocks_null_sink_0, '4']
- [pfb_channelizer_ccf_0, '4', qtgui_freq_sink_x_0_0, '0']
- [pfb_channelizer_ccf_0, '5', blocks_null_sink_0, '8']
- [pfb_channelizer_ccf_0, '6', blocks_null_sink_0, '5']
- [pfb_channelizer_ccf_0, '6', qtgui_freq_sink_x_0_0_0, '0']
- [pfb_channelizer_ccf_0, '7', blocks_null_sink_0, '6']
- [pfb_channelizer_ccf_0, '8', blocks_null_sink_0, '7']
- [pfb_channelizer_ccf_0, '9', blocks_null_sink_0, '9']
- [soapy_rtlsdr_source_0, '0', analog_agc2_xx_0, '0']
- [uhd_usrp_source_0, '0', analog_agc2_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
