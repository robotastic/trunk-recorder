options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fm_channelizer
    output_language: python
  states: {}

blocks:
- name: address
  id: variable
  parameters:
    value: '""'
  states: {}
- name: atten
  id: variable
  parameters:
    value: '60'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: 44.1e3
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '855462500'
  states: {}
- name: ch_bw
  id: variable
  parameters:
    value: '7250'
  states: {}
- name: ch_rate
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: ch_tb
  id: variable
  parameters:
    value: '1450'
  states: {}
- name: channel
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Channel
    start: '0'
    step: '1'
    stop: channels
    value: '0'
  states: {}
- name: channels
  id: variable
  parameters:
    value: '80'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '15'
  states: {}
- name: pfb_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, samp_rate, ch_bw, ch_tb, atten, window.WIN_HANN)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e5
  states: {}
- name: tun_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Gain (dB)
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: gain
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,2
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.1'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_wfm_rcv
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1 #int(ch_rate/audio_rate)'
    quad_rate: ch_rate
  states: {state: disabled}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: int(audio_rate)
  states: {state: disabled}
- name: blocks_multiply_const_vxx
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: audio_rate/50000
    type: fff
  states: {state: disabled}
- name: pfb_decimator_ccf_0
  id: pfb_decimator_ccf
  parameters:
    atten: '100'
    channel: channel
    decim: channels
    taps: pfb_taps
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,2
    name: QT GUI Plot
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: ch_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,1
    name: QT GUI Plot
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    label1: ''
    label2: ''
    name: QT GUI Plot
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    clock_rate: '0.0'
    clock_source0: gpsdo
    dev_addr: address
    gain0: tun_gain
    samp_rate: samp_rate
    sync: none
    time_source0: gpsdo
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc2_xx_0, '0', pfb_decimator_ccf_0, '0']
- [analog_agc2_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx, '0', audio_sink, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_multiply_const_vxx, '0']
- [pfb_decimator_ccf_0, '0', analog_wfm_rcv, '0']
- [pfb_decimator_ccf_0, '0', qtgui_freq_sink_x_0_0, '0']
- [pfb_decimator_ccf_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', analog_agc2_xx_0, '0']
- [soapy_plutosdr_source_0, '0', analog_agc2_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_agc2_xx_0, '0']
- [uhd_usrp_source_0, '0', analog_agc2_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
