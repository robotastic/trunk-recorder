options:
  parameters:
    author: Luke Berndt
    generate_options: qt_gui
    id: debug_recorder
    output_language: python
    title: Trunk Recorder Debug Monitor
  states: {}

blocks:
- name: address
  id: variable
  parameters:
    value: '"0.0.0.0"'
  states: {}
- name: port
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '1234'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Flickering
  id: note
  parameters:
    note: On OSX, if you are seeing a Flicker edit ~/.gnuradio/config.conf and add [qtgui] style = native
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: port
    src_zeros: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}

connections:
- [network_udp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [network_udp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
